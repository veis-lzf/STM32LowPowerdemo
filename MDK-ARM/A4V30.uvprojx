# Keil uVision project A4V30.uvprojx, settings and files
target A4V30 (6160000::V6.16::ARMCLANG)
  device: STM32G0B1RCTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: A4V30 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output D:/YW687/DemoCode/A4V30/OBJ/A4V30.bin D:/YW687/DemoCode/A4V30/OBJ/A4V30.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;    ../Drivers/STM32G0xx_HAL_Driver/Inc;    ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;    ../Drivers/CMSIS/Include;    ..\UsrApp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_iwdg.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group UsrApp
    ../UsrApp/src/: PowerManagement.c debug.c
software components: CMSIS:CORE 5.4.0
